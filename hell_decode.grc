options:
  parameters:
    author: Thomas Lavarenne
    description: Hellschreiber Receptor
    generate_options: qt_gui
    id: hell_decode
    output_language: python
    title: Hellschreiber receptor
  states: {}

blocks:
- name: noise
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '50'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise*1e-3
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: '0.15'
    init: '0'
    low: '0.15'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '203.85'
    ted_gain: '1.0'
    ted_type: digital.TED_MOD_MUELLER_AND_MULLER
    type: ff
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: 20*2
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 100e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: 1024*10
    srate: samp_rate/40
    type: float
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 866e6
    gain0: '30'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: 866e6
    dev_args: '""'
    gain0: '60'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:55555
    timeout: '100'
    type: byte
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_add_xx_0, '1']
- [blocks_float_to_uchar_0, '0', zeromq_pub_sink_0, '0']
- [blocks_threshold_ff_0_0, '0', blocks_float_to_uchar_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_threshold_ff_0_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
