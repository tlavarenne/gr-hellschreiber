options:
  parameters:
    author: JM Friedt / T. Lavarenne
    description: Hellschreiber Receptor
    generate_options: qt_gui
    id: hell_decode
    output_language: python
    title: Hellschreiber receptor
  states: {}

blocks:
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    start: '-65'
    step: '1'
    stop: '65'
    value: '0'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '1000'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-1'
    reference: '0.25'
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: '0.05'
    init: '0'
    low: '0.05'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    comment: |-
      propagation channel modeling
      (add noise and frequency offset)
    epsilon: '1.0'
    freq_offset: freq_offset*1e3
    noise_voltage: noise*1e-3
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '64'
    long_form: 'True'
    type: ff
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.025'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: 203.85/40
    ted_gain: '1.0'
    ted_type: digital.TED_MOD_MUELLER_AND_MULLER
    type: ff
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 60e3
    decim: 20*2
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 60e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate/40/40/5.09625
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate/40/20
    type: float
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '40'
    gain: '1'
    ntaps: '200'
    samp_rate: samp_rate/40
    sym_rate: '122.5'
    type: fir_filter_fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 866e6
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:55555
    timeout: '100'
    type: byte
  states: {}

connections:
- [analog_agc_xx_0, '0', dc_blocker_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_float_to_uchar_0, '0', zeromq_pub_sink_0, '0']
- [blocks_threshold_ff_0_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_threshold_ff_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [channels_channel_model_0, '0', low_pass_filter_0, '0']
- [dc_blocker_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [dc_blocker_xx_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_threshold_ff_0_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [root_raised_cosine_filter_0, '0', analog_agc_xx_0, '0']
- [rtlsdr_source_0, '0', channels_channel_model_0, '0']

metadata:
  file_format: 1
