options:
  parameters:
    author: Barry Duggan (adaptated for hellschreiber by T. Lavarenne)
    description: Hellschreiber code generator
    generate_options: qt_gui
    id: hell_encode
    output_language: python
    title: Hellschreiber Code Generator
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '0.01'
    stop: '1.0'
    value: '0.05'
    widget: slider
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Volume
    const: volume
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    comment: |-
      44100/360=122.5 
      hellschreiber baudrate
    interp: '360'
    type: byte
  states: {}
- name: blocks_repeat_1
  id: blocks_repeat
  parameters:
    interp: '23'
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Hellschreiber code vector source
      """

      #  epy_block_0.py
      #  revised 09/10/2019 - finish code table
      #  revised 09/11/2019 - test for bad character
      #  revised 09/27/2019 - get input from a Message Edit block (code from Volker Schroer dl1ksv)

      import numpy as np
      from gnuradio import gr
      import pmt

      textboxValue = ""

      Morse = {
        # codes from https://www.itu.int/rec/R-REC-M.1677-1-200910-I/en

      ' ':"0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0," ,
      'A':"0,0,0,0,0,0,0,0,0,0,0,0,0,0, \
           0,0,0,1,1,1,1,1,1,1,1,1,0,0, \
           0,0,1,1,1,0,0,1,1,0,0,0,0,0, \
           0,0,1,1,0,0,0,1,1,0,0,0,0,0, \
           0,0,1,1,1,0,0,1,1,0,0,0,0,0, \
           0,0,0,1,1,1,1,1,1,1,1,1,0,0, \
           0,0,0,0,0,0,0,0,0,0,0,0,0,0,", \

      'B':"0,0,0,0,0,0,0,0,0,0,0,0,0,0, \
           0,0,1,1,0,0,0,0,0,0,1,1,0,0, \
           0,0,1,1,1,1,1,1,1,1,1,1,0,0, \
           0,0,1,1,0,0,1,1,0,0,1,1,0,0, \
           0,0,1,1,0,0,1,1,0,0,1,1,0,0, \
           0,0,0,1,1,1,0,0,1,1,1,0,0,0, \
           0,0,0,0,0,0,0,0,0,0,0,0,0,0,", \

      'C':"0,0,0,0,0,0,0,0,0,0,0,0,0,0, \
           0,0,1,1,1,1,1,1,1,1,1,1,0,0, \
           0,0,1,1,0,0,0,0,0,0,1,1,0,0, \
           0,0,1,1,0,0,0,0,0,0,1,1,0,0, \
           0,0,1,1,0,0,0,0,0,0,1,1,0,0, \
           0,0,1,1,0,0,0,0,0,0,1,1,0,0, \
           0,0,0,0,0,0,0,0,0,0,0,0,0,0,", \

      'D':"0,0,0,0,0,0,0,0,0,0,0,0,0,0, \
           0,0,1,1,0,0,0,0,0,0,1,1,0,0, \
           0,0,1,1,1,1,1,1,1,1,1,1,0,0, \
           0,0,1,1,0,0,0,0,0,0,1,1,0,0, \
           0,0,1,1,0,0,0,0,0,0,1,1,0,0, \
           0,0,0,1,1,1,1,1,1,1,1,0,0,0, \
           0,0,0,0,0,0,0,0,0,0,0,0,0,0,", \

      'E':"0,0,0,0,0,0,0,0,0,0,0,0,0,0, \
           0,0,1,1,1,1,1,1,1,1,1,1,0,0, \
           0,0,1,1,0,0,1,1,0,0,1,1,0,0, \
           0,0,1,1,0,0,1,1,0,0,1,1,0,0, \
           0,0,1,1,0,0,0,0,0,0,1,1,0,0, \
           0,0,1,1,0,0,0,0,0,0,1,1,0,0, \
           0,0,0,0,0,0,0,0,0,0,0,0,0,0,", \

      'F':"0,0,0,0,0,0,0,0,0,0,0,0,0,0, \
           0,0,1,1,1,1,1,1,1,1,1,1,0,0, \
           0,0,1,1,0,0,1,1,0,0,0,0,0,0, \
           0,0,1,1,0,0,1,1,0,0,0,0,0,0, \
           0,0,1,1,0,0,0,0,0,0,0,0,0,0, \
           0,0,1,1,0,0,0,0,0,0,0,0,0,0, \
           0,0,0,0,0,0,0,0,0,0,0,0,0,0,", \

      'G':"0,0,0,0,0,0,0,0,0,0,0,0,0,0, \
           0,0,1,1,1,1,1,1,1,1,1,1,0,0, \
           0,0,1,1,0,0,0,0,0,0,1,1,0,0, \
           0,0,1,1,0,0,0,0,0,0,1,1,0,0, \
           0,0,1,1,0,0,1,1,0,0,1,1,0,0, \
           0,0,0,0,0,0,1,1,1,1,1,1,0,0, \
           0,0,0,0,0,0,0,0,0,0,0,0,0,0,", \

      'H':"0,0,0,0,0,0,0,0,0,0,0,0,0,0, \
           0,0,1,1,1,1,1,1,1,1,1,1,0,0, \
           0,0,0,0,0,0,1,1,0,0,0,0,0,0, \
           0,0,0,0,0,0,1,1,0,0,0,0,0,0, \
           0,0,0,0,0,0,1,1,0,0,0,0,0,0, \
           0,0,1,1,1,1,1,1,1,1,1,1,0,0, \
           0,0,0,0,0,0,0,0,0,0,0,0,0,0,", \

      'I':"0,0,0,0,0,0,0,0,0,0,0,0,0,0, \
           0,0,0,0,0,0,0,0,0,0,0,0,0,0, \
           0,0,0,0,0,0,0,0,0,0,0,0,0,0, \
           0,0,1,1,1,1,1,1,1,1,1,1,0,0, \
           0,0,0,0,0,0,0,0,0,0,0,0,0,0, \
           0,0,0,0,0,0,0,0,0,0,0,0,0,0, \
           0,0,0,0,0,0,0,0,0,0,0,0,0,0,", \

      'J':"0,0,0,0,0,0,0,0,0,0,0,0,0,0, \
           0,0,0,0,0,0,0,0,1,1,1,1,0,0, \
           0,0,0,0,0,0,0,0,0,0,1,1,0,0, \
           0,0,0,0,0,0,0,0,0,0,1,1,0,0, \
           0,0,0,0,0,0,0,0,0,0,1,1,0,0, \
           0,0,1,1,1,1,1,1,1,1,1,1,0,0, \
           0,0,0,0,0,0,0,0,0,0,0,0,0,0,", \

      'K':"0,0,0,0,0,0,0,0,0,0,0,0,0,0, \
           0,0,1,1,1,1,1,1,1,1,1,1,0,0, \
           0,0,0,0,0,0,1,1,0,0,0,0,0,0, \
           0,0,0,0,0,1,1,1,1,0,0,0,0,0, \
           0,0,0,0,1,1,0,0,1,1,0,0,0,0, \
           0,0,0,1,1,1,0,0,0,1,1,1,0,0, \
           0,0,0,0,0,0,0,0,0,0,0,0,0,0,", \

      'L':"0,0,0,0,0,0,0,0,0,0,0,0,0,0, \
           0,0,1,1,1,1,1,1,1,1,1,1,0,0, \
           0,0,0,0,0,0,0,0,0,0,1,1,0,0, \
           0,0,0,0,0,0,0,0,0,0,1,1,0,0, \
           0,0,0,0,0,0,0,0,0,0,1,1,0,0, \
           0,0,0,0,0,0,0,0,0,0,1,1,0,0, \
           0,0,0,0,0,0,0,0,0,0,0,0,0,0,", \

      'M':"0,0,0,0,0,0,0,0,0,0,0,0,0,0, \
           0,0,1,1,1,1,1,1,1,1,1,1,0,0, \
           0,0,0,1,1,0,0,0,0,0,0,0,0,0, \
           0,0,0,0,1,1,0,0,0,0,0,0,0,0, \
           0,0,0,1,1,0,0,0,0,0,0,0,0,0, \
           0,0,1,1,1,1,1,1,1,1,1,1,0,0, \
           0,0,0,0,0,0,0,0,0,0,0,0,0,0,", \

      'N':"0,0,0,0,0,0,0,0,0,0,0,0,0,0, \
           0,0,1,1,1,1,1,1,1,1,1,1,0,0, \
           0,0,0,1,1,1,0,0,0,0,0,0,0,0, \
           0,0,0,0,0,1,1,1,0,0,0,0,0,0, \
           0,0,0,0,0,0,0,1,1,1,0,0,0,0, \
           0,0,1,1,1,1,1,1,1,1,1,1,0,0, \
           0,0,0,0,0,0,0,0,0,0,0,0,0,0,", \

      'O':"0,0,0,0,0,0,0,0,0,0,0,0,0,0, \
           0,0,1,1,1,1,1,1,1,1,1,1,0,0, \
           0,0,1,1,0,0,0,0,0,0,1,1,0,0, \
           0,0,1,1,0,0,0,0,0,0,1,1,0,0, \
           0,0,1,1,0,0,0,0,0,0,1,1,0,0, \
           0,0,1,1,1,1,1,1,1,1,1,1,0,0, \
           0,0,0,0,0,0,0,0,0,0,0,0,0,0,", \

      'P':"0,0,0,0,0,0,0,0,0,0,0,0,0,0, \
           0,0,1,1,0,0,0,0,0,0,1,1,0,0, \
           0,0,1,1,1,1,1,1,1,1,1,1,0,0, \
           0,0,1,1,0,0,1,1,0,0,1,1,0,0, \
           0,0,1,1,0,0,1,1,0,0,0,0,0,0, \
           0,0,1,1,1,1,1,1,0,0,0,0,0,0, \
           0,0,0,0,0,0,0,0,0,0,0,0,0,0,", \

      'Q':"0,0,0,0,0,0,0,0,0,0,0,0,0,0, \
           0,0,0,1,1,1,1,1,1,1,1,0,0,0, \
           0,0,1,1,0,0,0,0,0,0,1,1,0,0, \
           0,0,1,1,0,0,0,0,0,0,1,1,0,0, \
           0,0,0,1,1,1,1,1,1,1,1,1,0,0, \
           0,0,0,0,0,0,0,0,0,0,1,1,1,1, \
           0,0,0,0,0,0,0,0,0,0,0,0,0,0,", \

      'R':"0,0,0,0,0,0,0,0,0,0,0,0,0,0, \
           0,0,1,1,1,1,1,1,1,1,1,1,0,0, \
           0,0,1,1,0,0,1,1,0,0,0,0,0,0, \
           0,0,1,1,0,0,1,1,0,0,0,0,0,0, \
           0,0,1,1,0,0,1,1,1,1,0,0,0,0, \
           0,0,0,1,1,1,1,0,0,1,1,1,0,0, \
           0,0,0,0,0,0,0,0,0,0,0,0,0,0,", \

      'S':"0,0,0,0,0,0,0,0,0,0,0,0,0,0, \
           0,0,0,1,1,1,1,0,0,0,1,1,0,0, \
           0,0,1,1,0,0,1,1,0,0,1,1,0,0, \
           0,0,1,1,0,0,1,1,0,0,1,1,0,0, \
           0,0,1,1,0,0,1,1,0,0,1,1,0,0, \
           0,0,1,1,0,0,0,1,1,1,1,0,0,0, \
           0,0,0,0,0,0,0,0,0,0,0,0,0,0,", \

      'T':"0,0,0,0,0,0,0,0,0,0,0,0,0,0, \
           0,0,1,1,0,0,0,0,0,0,0,0,0,0, \
           0,0,1,1,0,0,0,0,0,0,0,0,0,0, \
           0,0,1,1,1,1,1,1,1,1,1,1,0,0, \
           0,0,1,1,0,0,0,0,0,0,0,0,0,0, \
           0,0,1,1,0,0,0,0,0,0,0,0,0,0, \
           0,0,0,0,0,0,0,0,0,0,0,0,0,0,", \

      'U':"0,0,0,0,0,0,0,0,0,0,0,0,0,0, \
           0,0,1,1,1,1,1,1,1,1,1,1,0,0, \
           0,0,0,0,0,0,0,0,0,0,1,1,0,0, \
           0,0,0,0,0,0,0,0,0,0,1,1,0,0, \
           0,0,0,0,0,0,0,0,0,0,1,1,0,0, \
           0,0,1,1,1,1,1,1,1,1,1,1,0,0, \
           0,0,0,0,0,0,0,0,0,0,0,0,0,0,", \

      'V':"0,0,0,0,0,0,0,0,0,0,0,0,0,0, \
           0,0,1,1,1,1,1,1,1,1,1,1,0,0, \
           0,0,0,0,0,0,0,0,1,1,1,0,0,0, \
           0,0,0,0,0,0,1,1,1,0,0,0,0,0, \
           0,0,0,0,1,1,1,0,0,0,0,0,0,0, \
           0,0,1,1,1,0,0,0,0,0,0,0,0,0, \
           0,0,0,0,0,0,0,0,0,0,0,0,0,0,", \

      'W':"0,0,0,0,0,0,0,0,0,0,0,0,0,0, \
           0,0,1,1,1,1,1,1,1,1,1,0,0,0, \
           0,0,0,0,0,0,0,0,0,0,1,1,0,0, \
           0,0,0,0,0,0,1,1,1,1,1,0,0,0, \
           0,0,0,0,0,0,0,0,0,0,1,1,0,0, \
           0,0,1,1,1,1,1,1,1,1,1,0,0,0, \
           0,0,0,0,0,0,0,0,0,0,0,0,0,0,", \

      'X':"0,0,0,0,0,0,0,0,0,0,0,0,0,0, \
           0,0,1,1,1,0,0,0,0,1,1,1,0,0, \
           0,0,0,0,1,1,0,0,1,1,0,0,0,0, \
           0,0,0,0,0,1,1,1,1,0,0,0,0,0, \
           0,0,0,0,1,1,0,0,1,1,0,0,0,0, \
           0,0,1,1,1,0,0,0,0,1,1,1,0,0, \
           0,0,0,0,0,0,0,0,0,0,0,0,0,0,", \

      'Y':"0,0,0,0,0,0,0,0,0,0,0,0,0,0, \
           0,0,1,1,1,0,0,0,0,0,0,0,0,0, \
           0,0,0,0,1,1,1,0,0,0,0,0,0,0, \
           0,0,0,0,0,0,1,1,1,1,1,1,0,0, \
           0,0,0,0,1,1,1,0,0,0,0,0,0,0, \
           0,0,1,1,1,0,0,0,0,0,0,0,0,0, \
           0,0,0,0,0,0,0,0,0,0,0,0,0,0,", \

      'Z':"0,0,0,0,0,0,0,0,0,0,0,0,0,0, \
           0,0,1,1,0,0,0,0,0,1,1,1,0,0, \
           0,0,1,1,0,0,0,1,1,1,1,1,0,0, \
           0,0,1,1,0,0,1,1,0,0,1,1,0,0, \
           0,0,1,1,1,1,1,0,0,0,1,1,0,0, \
           0,0,1,1,1,0,0,0,0,0,1,1,0,0, \
           0,0,0,0,0,0,0,0,0,0,0,0,0,0,", \

      ':':"0,0,0,0,0,0,0,0,0,0,0,0,0,0, \
           0,0,0,0,0,0,0,0,0,0,0,0,0,0, \
           0,0,0,1,1,1,0,0,1,1,1,0,0,0, \
           0,0,0,1,1,1,0,0,1,1,1,0,0,0, \
           0,0,0,0,0,0,0,0,0,0,0,0,0,0, \
           0,0,0,0,0,0,0,0,0,0,0,0,0,0, \
           0,0,0,0,0,0,0,0,0,0,0,0,0,0"
            }

      class mc_sync_block(gr.sync_block):
          """
          reads input from a message port
          generates a vector of Hellschreiber code bits
          """
          def __init__(self):
              gr.sync_block.__init__(self, \
                  name = "Hellschreiber code vector source", \
                  in_sig = None, \
                  out_sig = [np.byte])
              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_out(pmt.intern('clear_input'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)

          def handle_msg(self, msg):
              global textboxValue
              textboxValue = pmt.symbol_to_string (msg)
              # print (textboxValue)
       
          def work(self, input_items, output_items):
              global Morse
              global textboxValue
              bit_stream = ""
              if (len (textboxValue) > 0):
                  for in0 in textboxValue:
                      # get next char
                      inChar = str (in0)
                      # convert to upper case
                      ch = inChar.upper()
                      # test for character in table
                      if (not(ch in Morse)):
                      # print ("bad char", ch)
                          ch = "?"        # replace bad character with a '?'
                      # build vector
                      _dots = str (Morse.get(ch))
                      # print (ch, _dots)
                      bit_stream += (_dots + "")    # letter space

                  bit_stream += "0"    # finish with word space
                  # print (bit_stream)

                  # get length of string
                  _len = len(bit_stream)
                  # num of elements = (length+1) / 2
                  _num_elem = int((_len+1) / 2)
               
                  # convert and store elements in output array
                  for x in range (_len):
                      y = int(x / 2)
                      if (bit_stream[x] == '1'):
                          output_items[0][y] = 1
                      elif (bit_stream[x] == '0'):
                          output_items[0][y] = 0
                      else:
                          continue    # skip commas

                  # clear input line
                  textboxValue = ""
                  self.message_port_pub(pmt.intern('clear_input'), pmt.intern(''))
              else:
                  _num_elem = 0

           
              return (_num_elem)
    comment: |-
      Python block from Barry Duggan's gr-code-morse-gen 
      adaptated for hellschreiber
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    key: '"text"'
    label: Input
    type: string
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    nconnections: '2'
    size: 16384*20
    srate: samp_rate
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '1.5'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: '200'
    samp_rate: samp_rate
    sym_rate: samp_rate/360
    type: fir_filter_fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 200e3
    center_freq0: 866e6
    gain0: '40'
    samp_rate: samp_rate*23
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_float_to_complex_0, '0', blocks_repeat_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_repeat_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_repeat_1, '0', uhd_usrp_sink_0, '0']
- [blocks_uchar_to_float_0, '0', root_raised_cosine_filter_0, '0']
- [epy_block_0_0, '0', blocks_repeat_0, '0']
- [epy_block_0_0, clear_input, qtgui_edit_box_msg_0, val]
- [qtgui_edit_box_msg_0, msg, epy_block_0_0, msg_in]
- [root_raised_cosine_filter_0, '0', blocks_float_to_complex_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_multiply_xx_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
